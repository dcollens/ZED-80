# Keil uVision project ER-TFTM101-1_8080-8bit.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C516RD+ STC89C58RD+ Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF7FF) CLOCK(45000000) MODP2
  output: sd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: RA8876.c
